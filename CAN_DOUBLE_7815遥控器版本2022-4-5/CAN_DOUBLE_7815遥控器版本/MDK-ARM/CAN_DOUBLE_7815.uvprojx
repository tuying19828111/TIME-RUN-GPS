# Keil uVision project CAN_DOUBLE_7815.uvprojx, settings and files
target CAN_DOUBLE_7815 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AC7815MBFE AutoChips
  pack: AutoChips.AC781x_DFP.1.1.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF)         CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CAN_DOUBLE_7815 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ../Inc;        ../Drivers/ATC_Driver/Inc;        ../Drivers/Device/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_ac78xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c i2c.c timer.c uart.c ac78xx_irq_cb.c ac78xx_msp.c system_ac78xx.c
  group Drivers/ATC_Driver
    ../Drivers/ATC_Driver/Src/: ac78xx_gpio.c ac78xx_can.c ac78xx_i2c.c ac78xx_dma.c ac78xx_timer.c ac78xx_uart.c
  group Drivers/Device
    ../Drivers/Device/Source/: ac78xx_ckgen.c ac78xx_spm.c
software components: CMSIS:CORE 5.0.1
